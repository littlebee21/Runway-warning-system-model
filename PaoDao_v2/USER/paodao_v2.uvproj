# Keil uVision project paodao_v2.uvproj, settings and files
target PaoDao (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: paodao_v2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HAREWARE;..\USER
  group USER
    ./: STARTUP.A51 main.c
    ../HAREWARE/: exti.c
  group HAREWARE
    ../HAREWARE/: chuankou.c led.c watch.c
